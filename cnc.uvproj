# Keil uVision project cnc.uvproj, settings and files
target CNC-STM32F10X (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cnc
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_HD
  c misc: --c99
  c include: .\src\application;.\src\libhardware\STM32F10X;.\src\liblcd;.\src\libtools;.\src\libcmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ./src/application/: main.c hw_config.c stepmotor.c gcode_exec.c gcode.c Crc32.c keyboard.c manualmode.c mass_mal.c memory.c rs232_interface.c scsi_data.c stm32f10x_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c encoder.c
  group libcmsis
    ./src/libcmsis/startup/arm/: startup_stm32f10x_hd.s startup_stm32f2xx.s startup_stm32f429_439xx.s
    ./src/libcmsis/: system_stm32f10x.c system_stm32f2xx.c system_stm32f4xx.c
  group liblcd
    ./src/liblcd/: scr_io.c ili9320_api.c ili9320.c ili9320_touch.c
  group libtools
    ./src/libtools/: rtc.c ff.c sdcard.c ccsbcs.c fattime.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c diskio.c
  group libhardware-STM32F10X
    ./src/libhardware/STM32F10X/: misc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_gpio.c stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c
  group libhardware-STM32F2XX
    ./src/libhardware/STM32F2XX/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group libhardware-STM32F4XX
    ./src/libhardware/STM32F4XX/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
target CNC-STM32F2XX (ARM-ADS)
  device: STM32F205VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(120000000) ELITTLE
  output: cnc
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F2XX
  c misc: --c99
  c include: .\src\application;.\src\libhardware\STM32F2XX;.\src\liblcd;.\src\libtools;.\src\libcmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target CNC-STM32F429I-DISCO (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: cnc
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F429_439xx
  c misc: --c99
  c include: .\src\application;.\src\libhardware\STM32F4XX;.\src\liblcd;.\src\libtools;.\src\libcmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
