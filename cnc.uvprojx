# Keil uVision project cnc.uvprojx, settings and files
target CNC-STM32F10X (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cnc
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_HD
  c misc: --c99
  c include: .\src\application;.\src\libhardware\STM32F10X-BOARD;.\src\libhardware\STM32F10X;.\src\libcmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./src/application/: main.c screen_io.c stepmotor.c gcode_exec.c gcode.c crc32.c manualmode.c rs232_interface.c interrupt.c encoder.c
  group STM32F10x_StdPeriph_Driver
    ./src/libhardware/STM32F10X/: stm32f10x_dma.c misc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_gpio.c stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c
  group STM32F4xx_StdPeriph_Driver
    ./src/libhardware/STM32F4XX/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_fmc.c
  group STM32F10X-BOARD
    ./src/application/: keyboard.c memory.c mass_mal.c scsi_data.c usb_scsi.c usb_pwr.c usb_prop.c usb_istr.c usb_endp.c usb_desc.c usb_bot.c
    ./src/libcmsis/: system_stm32f10x.c
    ./src/libhardware/STM32F10X-BOARD/: stm32f10x-board.c rtc.c ff.c sdcard.c ccsbcs.c fattime.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c diskio.c ili9320.c startup_stm32f10x_hd.s
  group STM32F429-DISCO
    ./src/libhardware/STM32F429I-DISCO/: startup_stm32f429_439xx.s stm32f429i-disco.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ioe.c
    ./src/libcmsis/: system_stm32f4xx.c
  group STM32F4-DISCO
    ./src/libhardware/STM32F4-DISCO/: startup_stm32f40_41xxx.s stm32f4_discovery.c
    ./src/libcmsis/: system_stm32f4xx.c
    ./src/application/: keyboard.c
  group STM32_USB_HOST_Library
    ./src/libhardware/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ./src/libhardware/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group STM32_USB_OTG_Driver
    ./src/libhardware/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group FatFs
    ./src/fat_fs/src/option/: ccsbcs.c
    ./src/libhardware/STM32F429I-DISCO/: fattime.c
    ./src/fat_fs/src/: ff.c
  group STM32_USB
    ./src/libhardware/STM32F429I-DISCO/: usbh_usr.c usb_bsp.c
target CNC-STM32F429I-DISCO (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: cnc
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F429_439xx
  c misc: --c99
  c include: .\src\application;.\src\libhardware\STM32F429I-DISCO;.\src\libhardware\STM32F4XX;.\src\libcmsis;.\src\fat_fs\inc;.\src\libhardware\STM32_USB_HOST_Library\Core\inc;.\src\libhardware\STM32_USB_HOST_Library\Class\MSC\inc;.\src\libhardware\STM32_USB_OTG_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target CNC-STM32F4-DISCO (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cnc
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F40_41xxx
  c misc: --c99
  c include: .\src\application;.\src\libhardware\STM32F4-DISCO;.\src\libhardware\STM32F4XX;.\src\libcmsis;.\src\fat_fs\inc;.\src\libhardware\STM32_USB_HOST_Library\Core\inc;.\src\libhardware\STM32_USB_HOST_Library\Class\MSC\inc;.\src\libhardware\STM32_USB_OTG_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
